# Keil uVision project HuaweiLiteOS.uvprojx, settings and files
target LiteOS (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HuaweiLiteOS
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\..\kernel\base\include;..\..\kernel\include;..\..\kernel\config;..\..\kernel\cmsis;..\..\kernel\link\keil;..\..\kernel\cpu\arm\cortex-m3;..\..\example\include;..\..\platform\expang_STM32F103;..\..\platform\expang_STM32F103\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\user;..\..\FatFS\src;..\..\platform\expang_STM32F103\Libraries\CMSIS\CM3\CoreSupport;..\..\platform\expang_STM32F103\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: ..\..\platform\expang_STM32F103\HuaweiLiteOS.sct
  group startup
    ../../platform/expang_STM32F103/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group libray
    ../../platform/expang_STM32F103/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group cmsis/cm3
    ../../platform/expang_STM32F103/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../platform/expang_STM32F103/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group kemel
    ../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../kernel/base/fs/: los_fs.c
    ../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../kernel/base/misc/: los_misc.c
  group cmsis/liteos
    ../../kernel/cmsis/: cmsis_liteos.c
  group cpu/m3
    ../../kernel/cpu/arm/cortex-m3/: los_hw.c los_hw_tick.c los_hwi.c los_dispatch_keil.s
  group config
    ../../kernel/config/: los_config.c
  group fatfs
    ../../FatFS/src/: diskio.c ff.c los_fs_adapter.c
    ../../FatFS/src/option/: cc936.c
  group platform/expang_STM32F103
    ../../platform/expang_STM32F103/: los_bsp_adapter.c los_bsp_flash.c los_bsp_key.c los_bsp_led.c los_bsp_uart.c
  group user
    ../../user/: main.c stm32f10x_it.c
  group example
    ../../example/api/: los_api_dynamic_mem.c los_api_event.c los_api_fs.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_cmsis_main.c los_demo_entry.c los_inspect_entry.c
  group bsp
    ../../user/bsp/usart/: bsp_debug_usart.c
    ../../user/bsp/systick/: bsp_SysTick.c
    ../../user/bsp/led/: bsp_led.c
    ../../user/bsp/key/: bsp_key.c
